# Keil uVision project Mykee.uvprojx, settings and files
target Abloy keyaxxess (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2368 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: MyKee +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: LPC12378 USE_LPC2378_STK
  c include: ..\src;..\src\nxp\devices\lpc23xx;..\src\common;..\src\cyclone_tcp;..\..\cyclone_tcp_demo;..\src\cyclone_crypto;..\src\Drivers\ADC;..\src\Drivers\I2C;..\src\Drivers\RTC;..\src\Drivers\SPI;..\src\Drivers\TIMER;..\src\Drivers\UART;..\src\Drivers\WDT;..\src\Middleware\BUZZER;..\src\Middleware\EEPROM;..\src\Middleware\KEYPAD;..\src\Middleware\LCD;..\src\Middleware\LED;..\src\Middleware\RELAY;..\src\Middleware\RFID;..\src\Middleware\AC_DC_VOLT;..\src\Middleware\CLOCK_CALNDR;..\src\Middleware\DOOR
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: .\lpc2378_flash.sct
  group MainSource
    ./: startup_lpc23xx.s retarget.c
    ../src/: debug.c target.c mci_menu.c login_menu.c protocol_comm.c readfifo.S telnet_server.c main.c common_func.c msg_menu.c display_msg.c util_menu.c key_menu.c aka_sys.c tcp_client_event.c ble_commn.c aesencriptionwipro.c tcp_client_hb.c tcp_client_fw.c task_management.c bio.c
  group Main Header
    ../src/: os_port_config.h net_config.h freertosconfig.h ticker_itrp.h menu_main.h sdcard_mci.h M25P16.h telnet_server.h tcp_client_event.h tcp_client_hb.h
  group Common Sources
    ../src/common/: os_port_none.c date_time.c str.c
    ../src/: cpu_endian.c
  group Common Headers
    ../src/common/: endian.h os_port.h os_port_none.h date_time.h str.h error.h debug.h
  group CycloneTCP Sources
    ../src/cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c net_misc.c ethernet_misc.c socket_misc.c
    ../src/cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c ipv4_misc.c
    ../src/cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c icmpv6.c mld.c ndp.c slaac.c
    ../src/cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../src/cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../src/cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../src/cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c dhcp_client_misc.c dhcp_client_fsm.c
    ../src/cyclone_tcp/dhcpv6/: dhcpv6_client.c dhcpv6_common.c dhcpv6_debug.c
    ../src/cyclone_tcp/igmp/: igmp_common.c igmp_host.c igmp_host_misc.c
    ../src/cyclone_tcp/drivers/phy/: dp83848_driver.c
    ../src/cyclone_tcp/drivers/mac/: lpc23xx_eth_driver.c
  group CycloneTCP Headers
    ../src/cyclone_tcp/core/: net.h net_mem.h nic.h ethernet.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h bsd_socket.h raw_socket.h
    ../src/cyclone_tcp/drivers/: lpc23xx_eth.h ksz8721.h
    ../src/cyclone_tcp/ipv4/: arp.h ipv4.h ipv4_frag.h icmp.h igmp.h
    ../src/cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h icmpv6.h mld.h ndp.h slaac.h
    ../src/cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../src/cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_common.h
    ../src/cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../src/cyclone_tcp/dhcp/: dhcp_client.h dhcp_common.h dhcp_debug.h
    ../src/cyclone_tcp/ftp/: ftp_client.h
    ../src/cyclone_tcp/dhcpv6/: dhcpv6_client.h dhcpv6_common.h dhcpv6_debug.h
  group Drivers
    ../src/Drivers/I2C/: i2c.c
    ../src/Drivers/SPI/: spi.c
    ../src/Drivers/WDT/: wdt.c
    ../src/Drivers/ADC/: adc.c
    ../src/Drivers/TIMER/: timer.c
    ../src/Drivers/RTC/: rtc.c
    ../src/Drivers/UART/: uart.c
  group Middleware
    ../src/Middleware/LED/: LED.c
    ../src/Middleware/RFID/: RFID.c
    ../src/Middleware/EEPROM/: EEPROM.c
    ../src/Middleware/LCD/: LCD.c
    ../src/Middleware/AC_DC_VOLT/: AC_DC_VOLT.c
    ../src/Middleware/BUZZER/: BUZZER.c
    ../src/Middleware/CLOCK_CALNDR/: CLOCK_CALNDR.c
    ../src/Middleware/DOOR/: DOOR.c
    ../src/Middleware/KEYPAD/: KEYPAD.c
